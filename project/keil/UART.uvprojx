# Keil uVision project UART.uvprojx, settings and files
target dieukhiendongco (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.1.0
  cpu: CPUTYPE("Cortex-M3") CLOCK(10000000) ESEL ELITTLE
  output: UART
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\..\project;..\..\lib\STM32F10x_StdPeriph_Driver\inc;..\..\lib\CMSIS\CM3\CoreSupport;..\..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm
  library: MicroLIB
  group lib
    ../../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_sdio.c stm32f10x_tim.c
    ../../lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group user
    ../: main.c stm32f10x_it.c system_stm32f10x.c
    ../../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h
